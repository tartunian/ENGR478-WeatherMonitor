# Keil uVision project WeatherMonitor.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WeatherMonitor
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4c123GH6PM PART_TM4C123GH6PM
  c include: C:\ti\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: i2clib.c i2clib.h main.c main.h startup_rvmdk.S
  group libs/ssd1306
    ./libs/ssd1306/: bit_manipulation.h oled_font.h oled_font_source_pro.c oled_font_source_pro.h ssd1306.c ssd1306.h ssd1306_info.h ssd1306_utils.c ssd1306_utils.h
  group libs
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
